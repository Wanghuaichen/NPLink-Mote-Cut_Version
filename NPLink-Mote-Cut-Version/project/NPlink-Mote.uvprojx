# Keil uVision project NPlink-Mote.uvprojx, settings and files
target NPLink-Mote (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L051C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: NPLink-Mote +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L051xx,USE_STM32L0538_DISCO,USE_HAL_DRIVER,USE_DEBUG, USE_BAND_780
  c misc: --C99
  c include: ..\hal\drivers\cmsis;..\hal\drivers\STM32L0xx_HAL_Driver\Inc;..\startup;..\hal\radio;..\hal\board;..\app;..\mac;..\osal;..\hal\board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group startup
    ../startup/: startup_stm32l051xx.s
  group hal/stm32
    ../hal/drivers/cmsis/: system_stm32l0xx.c
    ../hal/drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c
  group hal/radio
    ../hal/radio/sx1276/: sx1276.c
  group hal/board
    ../hal/board/: board.c delay.c gpio_board.c spi_board.c sx1276_board.c timer.c timer_board.c uart_board.c utilities.c rtc_board.c
    ../hal/drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c
  group osal
    ../osal/: osal_app.c osal_time.c osal.c osal_memory.c osal_tick.c osal_mutex.c
  group mac
    ../mac/: NPLink-Mote-Mac.lib LoraMac_osal.h LoRaMacUsr.h
  group app
    ../app/: app_osal.c stm32l0xx_hal_msp.c stm32l0xx_it.c main.c hal_osal.c WaterMeter.c
